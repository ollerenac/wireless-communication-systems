options:
  parameters:
    author: Wireless Comm Systems 2026
    generate_options: qt_gui
    id: ofdm_demo
    output_language: python
    title: OFDM Demo Educativo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Ruido sigma
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.1'
  states: {}
- name: qpsk_const
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: Fuente de bits {0,1}
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: 2 bits -> simbolo {0,1,2,3}
    k: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Indice -> punto QPSK X[k]
    D: '1'
    in_type: byte
    out_type: complex
    symbol_table: qpsk_const.points()
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: N simbolos -> vector OFDM
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: 'IFFT: X[k] -> x[n]'
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Copia ultimas CP_LEN muestras al inicio
    input_size: fft_size
    output_size: fft_size+cp_len
    rolloff_len: '0'
    len_tag_key: '""'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: 'AWGN plano: taps=[1], sin multipath'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_amp
    seed: '0'
    taps: '[1.0+0j]'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    comment: 'Quitar CP: muestras [CP_LEN : CP_LEN+N]'
    m: fft_size
    n: fft_size+cp_len
    offset: cp_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    comment: 'FFT: x[n] -> Y[k] = N*X[k]'
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Ecualizacion: dividir por N compensa ganancia IFFT->FFT'
    const: 1.0/fft_size
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decision dura QPSK
    constellation: qpsk_const
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    bus_connectivity: '[]'
    comment: Aqui iria el comparador BER
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"TX: Constelacion QPSK"'
    size: '1024'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    label1: Re
    label2: Im
    name: '"TX: Simbolo OFDM + CP (tiempo)"'
    size: fft_size+cp_len
    srate: samp_rate
    type: complex
    ylabel: Amplitud
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"red"'
    label1: Re
    label2: Im
    name: '"RX: Senal recibida (tiempo)"'
    size: fft_size+cp_len
    srate: samp_rate
    type: complex
    ylabel: Amplitud
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label: '"Ganancia relativa"'
    name: '"RX: Espectro OFDM (subportadoras)"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    name: '"RX: Constelacion post-ecualizacion"'
    size: '1024'
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_1, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
